# Keil uVision project 21B_KadirCelik_B181210057.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: 21B_KadirCelik_B181210057 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 21B_KadirCelik_B181210057.asm
