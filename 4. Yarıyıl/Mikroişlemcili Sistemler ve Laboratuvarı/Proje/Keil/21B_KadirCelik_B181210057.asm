		ORG 00H
		SJMP BASLA
		ORG 30H
			
BASLA:	MOV P1,#0FFH
		JB P1.0,BASLA
			
BAS:	MOV P3,#10H
		MOV A,#75H
		MOV P2,A
		ACALL DELAY
		
		MOV P3,#80H
		MOV A,#58H
		MOV P2,A
		ACALL DELAY
				
		MOV P3,#40H
		MOV A,#06H
		MOV P2,A
		ACALL DELAY	
					
		MOV P3,#20H
		MOV A,#7CH
		MOV P2,A
		ACALL DELAY
		DJNZ P1,BAS	

		MOV P2,#00H
		ACALL TIMER
		SJMP BASLA

BIRAK:  JNB P1.0, BIRAK
		MOV P2,#00H
		SJMP BAS

TIMER:	MOV R7,#0100D
		MOV TMOD,#01H
L2:		MOV TH0,#0DBH
		MOV TL0,#0FFH
		SETB TCON.4
L3:		JNB TCON.5,L3
		CLR TCON.4
		CLR TCON.5
		DJNZ R7,L2
		RET
		
DELAY:	MOV R0, #200
		DJNZ R0, $
		RET
		END